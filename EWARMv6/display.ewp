# IAR project display.ewp, settings and files
configuration STM32F405RG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Display; ..\Display\Font16x26; ..\Interface; ..\Libs\Basic; ..\; ..\STMlib\CMSIS\Device\ST\STM32F4xx\Include; ..\STMlib\StdPeriphDriver\; ..\STMlib\StdPeriphDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Out\DOTS.display.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../: analog_data.c init.c main.c process_handler.c stm32f4xx_it.c
  group CMSIS
    ../STMlib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../STMlib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Display
    ../Display/: display.c ssd1351.c
  group Display/Fonts
    ../Display/fonts/: font_4_normal.c font_4_underlined.c font_5_normal.c font_5_underlined.c font_6_normal.c font_6_underlined.c
  group Interface
    ../Interface/: buttons.c communication_protocol.c
  group Libs
    ../Libs/Basic/: crc16.c
  group StdPeriphDriver
    ../STMlib/StdPeriphDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
